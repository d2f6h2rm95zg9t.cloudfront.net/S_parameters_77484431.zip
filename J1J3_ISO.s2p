!Agilent Technologies,N5230A,US43500312,A.07.50.67
!Agilent N5230A: A.07.50.67
!Date: Thursday, March 05, 2015 11:23:43
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   1600 points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, 34.99 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -27.23 dB at 32.75 GHz (marker M1); lowest = -133.6 dB at 9.458 GHz (marker M2)
!   lowest |S11| = -36.2 dB at 15.06 GHz (marker M3), VSWR 1.03, Z = 49 - j1.17 ohm
!   |S11| at or under -10 dB: 83.33 MHz to 92.32 MHz (8.988 MHz wide, 10.2 % of centre); 338.8 MHz to 11.73 GHz (11.39 GHz wide, 189 % of centre); 12.22 GHz to 17.36 GHz (5.14 GHz wide, 34.8 % of centre)
!   |S22| runs from -23.1 to 43.8 dB; largest |S21 - S12| = 0.029
!   the Smith chart shows 135 MHz to 21.9 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 34.99 MHz  16.6  -75.2  -67.0  15.4
! 284.9 MHz  -8.9  -83.4  -84.1  -8.1
! 634.8 MHz  -14.3  -100.4  -98.1  -13.9
! 2.109 GHz  -27.2  -104.0  -102.7  -18.8
! 4.309 GHz  -16.4  -111.5  -108.8  -19.3
! 6.708 GHz  -20.7  -113.3  -107.8  -17.8
! 9.458 GHz  -12.3  -133.6  -113.4  -12.5
! 12.18 GHz  -9.9  -91.9  -100.2  -21.7
! 13.36 GHz  -20.1  -89.4  -95.6  -20.9
! 14.46 GHz  -19.4  -91.2  -99.4  -17.5
! 15.06 GHz  -36.2  -97.9  -107.0  -15.9
! 17.21 GHz  -10.8  -89.4  -92.2  -9.6
! 20.03 GHz  -3.7  -92.9  -89.4  -8.6
! 23.1 GHz  7.9  -78.1  -75.2  8.5
! 26.68 GHz  21.6  -47.4  -46.6  24.8
! 29.15 GHz  31.3  -35.1  -35.0  28.5
! 31.3 GHz  21.1  -31.3  -31.3  29.6
! 32.75 GHz  32.9  -27.2  -28.2  35.1
! 33.35 GHz  36.1  -33.2  -31.8  36.9
! 36.38 GHz  39.6  -47.1  -46.4  39.4
! 37.93 GHz  44.1  -45.6  -37.5  43.3
! 40 GHz  32.7  -52.1  -46.4  32.9
