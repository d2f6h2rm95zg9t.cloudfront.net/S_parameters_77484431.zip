!Agilent Technologies,N5230A,US43500312,A.07.50.67
!Agilent N5230A: A.07.50.67
!Date: Thursday, March 05, 2015 11:34:18
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   1600 points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, 34.99 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -24.36 dB at 34.18 GHz (marker M1); lowest = -129.3 dB at 1.36 GHz (marker M2)
!   lowest |S11| = -35.8 dB at 15.06 GHz (marker M3), VSWR 1.03, Z = 48.8 - j1.05 ohm
!   |S11| at or under -10 dB: 84.87 MHz to 85.61 MHz (745.6 kHz wide, 0.875 % of centre); 344.7 MHz to 11.53 GHz (11.19 GHz wide, 188 % of centre); 12.4 GHz to 17.22 GHz (4.816 GHz wide, 32.5 % of centre)
!   |S22| runs from -22.6 to 43.9 dB; largest |S21 - S12| = 0.019
!   the Smith chart shows 4.384 GHz to 20.88 GHz only
!   S11 on the Smith chart (normalised r, x): 4.384 GHz: 1.16, +0.29; 9.633 GHz: 1.46, -0.45; 17.11 GHz: 1.23, +0.65; 19.81 GHz: 2.57, +2.63; 20.88 GHz: -0.14, +1.77
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 34.99 MHz  16.1  -69.0  -68.6  14.9
! 284.9 MHz  -8.7  -80.5  -78.6  -8.6
! 1.36 GHz  -20.2  -129.3  -108.9  -19.9
! 2.209 GHz  -27.3  -100.9  -107.4  -20.9
! 4.384 GHz  -16.4  -110.9  -102.8  -21.4
! 6.708 GHz  -20.6  -109.2  -104.9  -14.5
! 9.633 GHz  -11.7  -115.1  -111.8  -8.4
! 13.36 GHz  -19.6  -96.8  -90.1  -9.0
! 14.46 GHz  -18.6  -92.7  -103.3  -7.7
! 15.06 GHz  -35.8  -93.8  -87.9  -7.2
! 17.11 GHz  -10.6  -90.6  -90.9  -5.9
! 19.81 GHz  -3.2  -87.3  -92.4  -7.5
! 20.03 GHz  -2.2  -86.3  -84.2  -8.2
! 20.88 GHz  0.6  -84.7  -87.5  -6.8
! 24.7 GHz  14.5  -69.3  -60.4  21.7
! 26.68 GHz  28.9  -51.7  -55.7  31.0
! 28.65 GHz  39.9  -34.5  -36.2  32.9
! 31.3 GHz  23.5  -37.2  -35.9  30.6
! 33.35 GHz  34.8  -28.3  -28.0  35.9
! 34.18 GHz  37.2  -24.4  -24.7  38.9
! 36.78 GHz  41.0  -62.4  -46.7  41.1
! 40 GHz  28.2  -50.2  -55.2  28.3
