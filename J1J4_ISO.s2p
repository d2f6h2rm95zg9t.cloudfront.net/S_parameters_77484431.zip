!Agilent Technologies,N5230A,US43500312,A.07.50.67
!Agilent N5230A: A.07.50.67
!Date: Thursday, March 05, 2015 11:29:01
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   1600 points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, 34.99 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -34.21 dB at 33.58 GHz (marker M1); lowest = -136.5 dB at 7.808 GHz (marker M2)
!   lowest |S11| = -29.3 dB at 6.933 GHz (marker M3), VSWR 1.07, Z = 46.8 + j0.668 ohm
!   |S11| at or under -10 dB: 318 MHz to 11.17 GHz (10.85 GHz wide, 189 % of centre); 12.95 GHz to 17.17 GHz (4.222 GHz wide, 28 % of centre); 17.75 GHz to 20.45 GHz (2.697 GHz wide, 14.1 % of centre)
!   |S22| runs from -36.6 to 41.3 dB; largest |S21 - S12| = 0.021
!   the Smith chart shows 84.98 MHz to 19.48 GHz only
!   S11 on the Smith chart (normalised r, x): 84.98 MHz: 0.48, -0.05; 409.9 MHz: 1.14, -0.56; 7.933 GHz: 0.82, -0.32; 12.53 GHz: 1.38, +0.98; 16.38 GHz: 0.81, +0.19; 19.48 GHz: 1.34, -0.25
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 34.99 MHz  17.1  -55.9  -55.9  16.5
! 84.98 MHz  -8.9  -65.0  -64.9  -4.6
! 409.9 MHz  -11.6  -86.6  -85.4  -10.9
! 5.909 GHz  -16.4  -102.6  -104.5  -23.4
! 6.708 GHz  -24.9  -104.4  -105.5  -22.4
! 6.933 GHz  -29.3  -105.3  -107.6  -22.2
! 7.808 GHz  -14.9  -136.5  -105.4  -19.8
! 7.933 GHz  -14.1  -105.7  -103.2  -19.1
! 9.758 GHz  -16.9  -97.6  -106.1  -20.8
! 10.86 GHz  -12.5  -93.6  -96.5  -35.5
! 12.53 GHz  -7.8  -97.1  -88.4  -17.5
! 13.36 GHz  -14.3  -89.0  -93.2  -14.1
! 13.98 GHz  -23.7  -84.7  -90.3  -12.3
! 16.38 GHz  -16.6  -96.4  -96.9  -8.9
! 19.48 GHz  -14.9  -103.5  -84.6  -3.8
! 20.03 GHz  -14.8  -84.0  -84.5  -2.6
! 24.55 GHz  10.1  -76.3  -76.7  10.5
! 26.68 GHz  21.5  -69.7  -62.3  19.8
! 31.4 GHz  30.6  -37.4  -45.2  36.7
! 33.35 GHz  39.8  -39.4  -41.0  40.7
! 33.58 GHz  40.0  -34.2  -43.7  41.0
! 40 GHz  19.9  -72.9  -70.3  17.4
